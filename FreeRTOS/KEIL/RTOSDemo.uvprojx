# Keil uVision project RTOSDemo.uvprojx, settings and files
target FreeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: M453VG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.11
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: RTOSDemo +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: RVDS_ARMCM4_NUC4xx
  c include: ..\..\Library\CMSIS\Include;..\..\Library\StdDriver\inc;..\..\Library\Device\Nuvoton\M451Series\Include;..\..\ThirdParty\FreeRTOS\SOURCE\include;..\..\ThirdParty\FreeRTOS\Demo\COMMON\include;..\..\ThirdParty\FreeRTOS\SOURCE\portable\RVDS\ARM_CM4F;..\..\FreeRTOS;..\..\Library\NuEdu\inc;..\GCC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group System
    ../../Library/Device/Nuvoton/M451Series/Source/: system_M451Series.c
    ../../Library/Device/Nuvoton/M451Series/Source/ARM/: startup_M451Series.s
  group Demo Files
    ../: main.c
    ../../ThirdParty/FreeRTOS/DEMO/COMMON/Minimal/: QueueSet.c PollQ.c taskLed7Segm.c taskLedToggle.c taskTimer1.c taskWatchdog.c taskWWatchdog.c taskRTC.c
  group FreeRTOS files
    ../../ThirdParty/FreeRTOS/SOURCE/: tasks.c timers.c list.c queue.c
    ../../ThirdParty/FreeRTOS/SOURCE/portable/RVDS/ARM_CM4F/: port.c
    ../../ThirdParty/FreeRTOS/SOURCE/portable/MemMang/: heap_2.c
  group lib
    ../../Library/StdDriver/src/: retarget.c sys.c uart.c clk.c gpio.c timer.c wdt.c wwdt.c rtc.c
  group NuEdu
    ../../Library/NuEdu/src/: NuEdu-Basic01_7_Segment.c
software components: CMSIS:CORE 5.4.0
